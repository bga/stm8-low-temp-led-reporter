# IAR project stm8-volt-amper-meter-iar.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 2
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.PreInclude: ..\config.h
  ICCSTM8.CCIncludePath2: ..\lib\stm8-bare-min\stm8s\lib; ..\lib\!mcu\include; ..\lib\!cpp\include
  ICCSTM8.IccLang: 2
  OBJCOPY.OOCOutputFile: stm8-volt-amper-meter-iar.srec
  ILINK.IlinkOutputFile: app.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: NDEBUG
  group src
    ../src/: main.cpp
  group stm8s-bare-min
    ../lib/stm8-bare-min/stm8s/lib/: delay.h delay.c eeprom.c stm8s.h
    ../lib/stm8-bare-min/stm8s/lib/stm8-bare-min/: eeprom.h
